<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32U5G9J-DK2.ewp</path>
  </project>
  <batchBuild />
</workspace>
